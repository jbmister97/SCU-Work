<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ELEN460_HW2.ewp</path>
  </project>
  <batchBuild />
</workspace>
