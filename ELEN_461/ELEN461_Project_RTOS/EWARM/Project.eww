<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ELEN461_Project_RTOS.ewp</path>
  </project>
  <batchBuild />
</workspace>
