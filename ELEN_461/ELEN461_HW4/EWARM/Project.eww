<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ELEN461_HW4.ewp</path>
  </project>
  <batchBuild />
</workspace>
