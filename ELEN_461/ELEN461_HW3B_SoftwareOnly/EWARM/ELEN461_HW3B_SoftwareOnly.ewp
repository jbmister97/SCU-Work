# IAR project ELEN461_HW3B_SoftwareOnly.ewp, settings and files
configuration ELEN461_HW3B_SoftwareOnly (ARM, debug)
  General.OGChipSelectEditMenu: STM32L031K6 ST STM32L031K6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L031xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; C:\GitHub\SCU-Work\ELEN_461\ELEN461_HW3B_SoftwareOnly\Core\Modules\UX; C:\GitHub\SCU-Work\ELEN_461\ELEN461_HW3B_SoftwareOnly\Core\Modules\KeyboardHoldRepeat; C:\GitHub\SCU-Work\ELEN_461\ELEN461_HW3B_SoftwareOnly\Core\Modules\Conversions; C:\GitHub\SCU-Work\ELEN_461\ELEN461_HW3B_SoftwareOnly\Drivers\SSD1306\OLED\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ELEN461_HW3B_SoftwareOnly.hex
  ILINK.IlinkOutputFile: ELEN461_HW3B_SoftwareOnly.out
  ILINK.IlinkIcfFile: stm32l031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l031xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Application/User/Modules
    ../Core/Modules/UX/: ux_manager.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/SSD1306
    ../Drivers/SSD1306/OLED/Src/: fonts.c ssd1306.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
