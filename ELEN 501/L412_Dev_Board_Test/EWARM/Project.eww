<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\L412_Dev_Board_Test.ewp</path>
  </project>
  <batchBuild />
</workspace>
