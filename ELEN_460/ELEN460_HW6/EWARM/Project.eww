<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ELEN460_HW6.ewp</path>
  </project>
  <batchBuild />
</workspace>
