# IAR project ELEN460_Final_Project_Main.ewp, settings and files
configuration ELEN460_Final_Project_Main (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431KB ST STM32G431KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G431xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; C:\GitHub\SCU-Work\ELEN_460\ELEN460_Final_Project_Main\Core\Modules\KeyboardHoldRepeat
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ELEN460_Final_Project_Main.hex
  ILINK.IlinkOutputFile: ELEN460_Final_Project_Main.out
  ILINK.IlinkIcfFile: stm32g431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Modules/KeyboardHoldRepeat/: KeyboardHoldRepeat.c KeyboardHoldRepeat_User.c
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
