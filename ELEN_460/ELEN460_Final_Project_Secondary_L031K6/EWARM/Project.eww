<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ELEN460_Final_Project_Secondary_L031K6.ewp</path>
  </project>
  <batchBuild />
</workspace>
