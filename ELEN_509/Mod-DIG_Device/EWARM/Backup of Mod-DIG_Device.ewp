# IAR project Backup of Mod-DIG_Device.ewp, settings and files
configuration Mod-DIG_Device (ARM, debug)
  General.OGChipSelectEditMenu: STM32L010K4 ST STM32L010K4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L010x4
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\Core\Modules\Serial_Mult; ..\Core\Modules\Conversions
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Mod-DIG_Device.hex
  ILINK.IlinkOutputFile: Mod-DIG_Device.out
  ILINK.IlinkIcfFile: stm32l010x4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l010x4.s
  group Application/User/Core
    ../Core/Src/: Seven_Seg_2Digit.c main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Application/User/Modules
    ../Core/Modules/Conversions/: ASCII_numbers.c
    ../Core/Modules/Serial_Mult/: Serial.c serial_user.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/STM32L0xx_LL
    ../../MOD_DIG_BUS_DEVICE/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_lpuart.c
