<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Mod-DIG_Device.ewp</path>
  </project>
  <batchBuild />
</workspace>
