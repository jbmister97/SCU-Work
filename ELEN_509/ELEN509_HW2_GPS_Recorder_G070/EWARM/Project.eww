<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ELEN509_HW2_GPS_Recorder_G070.ewp</path>
  </project>
  <batchBuild />
</workspace>
